Commit message: fix pid controller

File: urdf/drone.urdf (robot description, URDF)
Before this commit: robot simple_drone, 2 links, 1 joints
Links:
- removed link quat_drone
- added link drone; visual box size=0.8 0.6 0.01
Joints:
- joint base_joint_kalman: child quat_drone -> drone
